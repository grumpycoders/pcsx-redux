/***************************************************************************
 *   Copyright (C) 2026 PCSX-Redux authors                                 *
 *                                                                         *
 *   This program is free software; you can redistribute it and/or modify  *
 *   it under the terms of the GNU General Public License as published by  *
 *   the Free Software Foundation; either version 2 of the License, or     *
 *   (at your option) any later version.                                   *
 *                                                                         *
 *   This program is distributed in the hope that it will be useful,       *
 *   but WITHOUT ANY WARRANTY; without even the implied warranty of        *
 *   MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the         *
 *   GNU General Public License for more details.                          *
 *                                                                         *
 *   You should have received a copy of the GNU General Public License     *
 *   along with this program; if not, write to the                         *
 *   Free Software Foundation, Inc.,                                       *
 *   51 Franklin Street, Fifth Floor, Boston, MA 02110-1301 USA.           *
 ***************************************************************************/

#include "supportpsx/psyq-obj.h"

#include <stdint.h>

#include <filesystem>
#include <string>

#include "elfio/elfio.hpp"
#include "gtest/gtest.h"
#include "support/file.h"

namespace {

// gprel16_addend.s, assembled with aspsx -G8 by abelbriggs1 (pcsx-redux PR 2292):
//
//         .sdata
// sd:     .word   1
//         .word   2
//         .lcomm  pad,4
//         .lcomm  lc,8
//         .comm   gc,8
//         .text
// f:      lw      $2,sd+4
//         lw      $3,lc+4
//         lw      $4,gc+4
//         j       $31
//
// Each load must reach its symbol plus 4. With comm symbols converted to .sbss,
// sd is .sdata+0, lc is .sbss+8 and gc is .sbss+16.

const uint8_t gprel16_267[] = {
    0x4c, 0x4e, 0x4b, 0x02, 0x2e, 0x07, 0x10, 0x01, 0x00, 0x00, 0x00, 0x08, 0x06, 0x2e, 0x72, 0x64, 0x61, 0x74, 0x61,
    0x10, 0x02, 0x00, 0x00, 0x00, 0x08, 0x05, 0x2e, 0x74, 0x65, 0x78, 0x74, 0x10, 0x03, 0x00, 0x00, 0x00, 0x08, 0x05,
    0x2e, 0x64, 0x61, 0x74, 0x61, 0x10, 0x04, 0x00, 0x00, 0x00, 0x08, 0x06, 0x2e, 0x73, 0x64, 0x61, 0x74, 0x61, 0x10,
    0x05, 0x00, 0x00, 0x00, 0x08, 0x05, 0x2e, 0x73, 0x62, 0x73, 0x73, 0x10, 0x06, 0x00, 0x00, 0x00, 0x08, 0x04, 0x2e,
    0x62, 0x73, 0x73, 0x10, 0x07, 0x00, 0x00, 0x00, 0x08, 0x06, 0x2e, 0x63, 0x74, 0x6f, 0x72, 0x73, 0x10, 0x08, 0x00,
    0x00, 0x00, 0x08, 0x06, 0x2e, 0x64, 0x74, 0x6f, 0x72, 0x73, 0x06, 0x02, 0x00, 0x06, 0x04, 0x00, 0x02, 0x08, 0x00,
    0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x02, 0x00, 0x02, 0x18, 0x00, 0x00, 0x00, 0x82, 0x8f, 0x00,
    0x00, 0x83, 0x8f, 0x00, 0x00, 0x04, 0x3c, 0x00, 0x00, 0x84, 0x8c, 0x08, 0x00, 0xe0, 0x03, 0x00, 0x00, 0x00, 0x00,
    0x0a, 0x1e, 0x00, 0x00, 0x2e, 0x0c, 0x04, 0x00, 0x2c, 0x04, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0a, 0x1e,
    0x04, 0x00, 0x2e, 0x0c, 0x04, 0x00, 0x2c, 0x04, 0x05, 0x00, 0x00, 0x0c, 0x00, 0x00, 0x00, 0x0a, 0x52, 0x08, 0x00,
    0x2c, 0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x09, 0x00, 0x0a, 0x54, 0x0c, 0x00, 0x2c, 0x00, 0x04, 0x00, 0x00, 0x00,
    0x02, 0x09, 0x00, 0x06, 0x05, 0x00, 0x08, 0x10, 0x00, 0x00, 0x00, 0x06, 0x02, 0x00, 0x12, 0x05, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x03, 0x70, 0x61, 0x64, 0x30, 0x09, 0x00, 0x05, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x67, 0x63, 0x12,
    0x05, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x6c, 0x63, 0x00};

const uint8_t gprel16_277[] = {
    0x4c, 0x4e, 0x4b, 0x02, 0x2e, 0x07, 0x10, 0x01, 0x00, 0x00, 0x00, 0x08, 0x06, 0x2e, 0x72, 0x64, 0x61, 0x74,
    0x61, 0x10, 0x02, 0x00, 0x00, 0x00, 0x08, 0x05, 0x2e, 0x74, 0x65, 0x78, 0x74, 0x10, 0x03, 0x00, 0x00, 0x00,
    0x08, 0x05, 0x2e, 0x64, 0x61, 0x74, 0x61, 0x10, 0x04, 0x00, 0x00, 0x00, 0x08, 0x06, 0x2e, 0x73, 0x64, 0x61,
    0x74, 0x61, 0x10, 0x05, 0x00, 0x00, 0x00, 0x08, 0x05, 0x2e, 0x73, 0x62, 0x73, 0x73, 0x10, 0x06, 0x00, 0x00,
    0x00, 0x08, 0x04, 0x2e, 0x62, 0x73, 0x73, 0x10, 0x07, 0x00, 0x00, 0x00, 0x08, 0x06, 0x2e, 0x63, 0x74, 0x6f,
    0x72, 0x73, 0x10, 0x08, 0x00, 0x00, 0x00, 0x08, 0x06, 0x2e, 0x64, 0x74, 0x6f, 0x72, 0x73, 0x06, 0x02, 0x00,
    0x06, 0x04, 0x00, 0x02, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x02, 0x00, 0x02,
    0x14, 0x00, 0x00, 0x00, 0x82, 0x8f, 0x00, 0x00, 0x83, 0x8f, 0x00, 0x00, 0x84, 0x8f, 0x08, 0x00, 0xe0, 0x03,
    0x00, 0x00, 0x00, 0x00, 0x0a, 0x64, 0x00, 0x00, 0x2c, 0x04, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0a,
    0x64, 0x04, 0x00, 0x2c, 0x04, 0x05, 0x00, 0x00, 0x0c, 0x00, 0x00, 0x00, 0x0a, 0x64, 0x08, 0x00, 0x2c, 0x00,
    0x04, 0x00, 0x00, 0x00, 0x02, 0x09, 0x00, 0x06, 0x05, 0x00, 0x08, 0x10, 0x00, 0x00, 0x00, 0x06, 0x02, 0x00,
    0x12, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x70, 0x61, 0x64, 0x30, 0x09, 0x00, 0x05, 0x00, 0x08, 0x00,
    0x00, 0x00, 0x02, 0x67, 0x63, 0x12, 0x05, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x6c, 0x63, 0x00};

struct Converted {
    ELFIO::elfio elf;
    ELFIO::section* text = nullptr;
};

void convert(const uint8_t* data, size_t size, const char* name, Converted& out) {
    PCSX::IO<PCSX::File> file(new PCSX::BufferFile(const_cast<uint8_t*>(data), size));
    auto psyq = PCSX::PsyqLnkFile::parse(file, false, false, true);
    ASSERT_NE(psyq, nullptr);
    auto path = (std::filesystem::temp_directory_path() / name).string();
    ASSERT_TRUE(psyq->writeElf("", path, true, false)) << psyq->elfConversionError;
    ASSERT_TRUE(out.elf.load(path));
    std::filesystem::remove(path);
    for (auto& sec : out.elf.sections) {
        if (sec->get_name() == ".text") out.text = sec.get();
    }
    ASSERT_NE(out.text, nullptr);
}

uint32_t word(const ELFIO::section* text, uint32_t offset) {
    auto p = reinterpret_cast<const uint8_t*>(text->get_data()) + offset;
    return p[0] | (p[1] << 8) | (p[2] << 16) | (p[3] << 24);
}

struct Reloc {
    unsigned type;
    std::string symbol;
};

// Returns the relocation applied at `offset` in .text, as type and the name of
// the symbol it is against (the section name for a section symbol).
Reloc relocAt(Converted& c, uint32_t offset) {
    Reloc ret = {0, ""};
    ELFIO::section* symtab = nullptr;
    for (auto& sec : c.elf.sections) {
        if (sec->get_type() == ELFIO::SHT_SYMTAB) symtab = sec.get();
    }
    for (auto& sec : c.elf.sections) {
        if (sec->get_type() != ELFIO::SHT_REL || sec->get_info() != c.text->get_index()) continue;
        ELFIO::const_relocation_section_accessor rel(c.elf, sec.get());
        ELFIO::const_symbol_section_accessor syms(c.elf, symtab);
        for (ELFIO::Elf_Xword i = 0; i < rel.get_entries_num(); i++) {
            ELFIO::Elf64_Addr off;
            ELFIO::Elf_Word sym;
            unsigned type;
            ELFIO::Elf_Sxword addend;
            rel.get_entry(i, off, sym, type, addend);
            if (off != offset) continue;
            std::string name;
            ELFIO::Elf64_Addr value;
            ELFIO::Elf_Xword size;
            unsigned char bind, symType, other;
            ELFIO::Elf_Half shndx;
            syms.get_symbol(sym, name, value, size, bind, symType, shndx, other);
            if (symType == ELFIO::STT_SECTION) name = c.elf.sections[shndx]->get_name();
            ret = {type, name};
        }
    }
    return ret;
}

constexpr unsigned R_MIPS_HI16 = 5;
constexpr unsigned R_MIPS_LO16 = 6;
constexpr unsigned R_MIPS_GPREL16 = 7;

}  // namespace

TEST(PsyqObj, GPREL16AddendAspsx277) {
    Converted c;
    convert(gprel16_277, sizeof(gprel16_277), "psyq-obj-gprel16-277.o", c);
    if (HasFatalFailure()) return;

    // lw $2, sd+4
    EXPECT_EQ(word(c.text, 0), 0x8f820004u);
    auto r = relocAt(c, 0);
    EXPECT_EQ(r.type, R_MIPS_GPREL16);
    EXPECT_EQ(r.symbol, ".sdata");

    // lw $3, lc+4
    EXPECT_EQ(word(c.text, 4), 0x8f83000cu);
    r = relocAt(c, 4);
    EXPECT_EQ(r.type, R_MIPS_GPREL16);
    EXPECT_EQ(r.symbol, ".sbss");

    // lw $4, gc+4
    EXPECT_EQ(word(c.text, 8), 0x8f840014u);
    r = relocAt(c, 8);
    EXPECT_EQ(r.type, R_MIPS_GPREL16);
    EXPECT_EQ(r.symbol, ".sbss");
}

TEST(PsyqObj, GPREL16AddendAspsx267) {
    Converted c;
    convert(gprel16_267, sizeof(gprel16_267), "psyq-obj-gprel16-267.o", c);
    if (HasFatalFailure()) return;

    // 2.67 emits GPREL16 LE for the local symbols.
    EXPECT_EQ(word(c.text, 0), 0x8f820004u);
    auto r = relocAt(c, 0);
    EXPECT_EQ(r.type, R_MIPS_GPREL16);
    EXPECT_EQ(r.symbol, ".sdata");

    EXPECT_EQ(word(c.text, 4), 0x8f83000cu);
    r = relocAt(c, 4);
    EXPECT_EQ(r.type, R_MIPS_GPREL16);
    EXPECT_EQ(r.symbol, ".sbss");

    // ...and a lui/lw pair for gc, the addend split across HI16/LO16.
    EXPECT_EQ(word(c.text, 8), 0x3c040000u);
    r = relocAt(c, 8);
    EXPECT_EQ(r.type, R_MIPS_HI16);
    EXPECT_EQ(r.symbol, ".sbss");
    EXPECT_EQ(word(c.text, 12), 0x8c840014u);
    r = relocAt(c, 12);
    EXPECT_EQ(r.type, R_MIPS_LO16);
    EXPECT_EQ(r.symbol, ".sbss");
}
